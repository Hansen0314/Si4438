<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Reciver_4438_494.5M.ewp</path>
  </project>
  <batchBuild/>
</workspace>


