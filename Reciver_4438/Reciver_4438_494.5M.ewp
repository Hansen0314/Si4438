# IAR project Reciver_4438_494.5M.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ; STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Reciver_4438_494.5M.hex
  ILINK.IlinkOutputFile: Reciver_4438_494.5M.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: ; 4438\; STM8L15x_StdPeriph_Driver\inc
  OBJCOPY.OOCOutputFile: Demo.hex
  ILINK.IlinkOutputFile: Demo.out
  group 443X
    443x/: radio.c radio_comm.c radio_hal.c radio_hal.h si446x_api_lib.c
  group Bsp
    Bsp/: 24c0x.c command.c flash.c init.c
  group STM8L15x_StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_tim4.c
  group User
    ./: include.h main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h
